Commit message: Change size of small box.

File: urdf/small_box.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.055 0.055 0.11; visual box size=0.055 0.055 0.11
